DEPENDS_remove = "gstreamer1.0-plugins-bad"
DEPENDS_append = " gstreamer1.0-codecparsers"
